# Keil uVision project modular_pinSetup.uvprojx, settings and files
target STM32F4 (6190000::V6.19::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: modular_pinSetup
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: main.c gpio.c delay.c
  group header
    ./: gpio.h delay.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
